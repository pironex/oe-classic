require orc.inc
#SRC_URI[orc.md5sum] = "e482932e544c847761449b106ecbc483"
#SRC_URI[orc.sha256sum] = "700e4edba20a0ed42164b645da26ce515b883d4c4633b222302f1e541f2a58ab"

SRC_URI[orc.md5sum] = "af1bf3dab9e69f3c36f389285e2a12a1"
SRC_URI[orc.sha256sum] = "4fc7cca48c59fff23afee78fb642cdbde001f56401c8f47b95a16578d1d5d7e8"
